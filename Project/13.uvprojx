# Keil uVision project 13.uvprojx, settings and files
target 13 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 13
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS;..\Library\inc;..\SYS;..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c gps.c
    ../SYS/: usart3_gps.c
  group STARTUP
    ../Library/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group SYS
    ../SYS/: bsp_SysTick.c delay.c sys.c usart1.c
    ../User/: led.c tough.c
